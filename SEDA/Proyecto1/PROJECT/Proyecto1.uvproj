# Keil uVision project Proyecto1.uvproj, settings and files
target LPC1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Proyecto1
  c flags: Optim=1
  c define: NO_RTX_KERNEL
  c include: ..\Libraries\LPC1700CMSIS_Firmware_Library\include;..\USER;..\Libraries\GLCD
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    C:/Keil/ARM/Startup/NXP/LPC17xx/: system_LPC17xx.c startup_LPC17xx.s
  group GLCD
    ../Libraries/GLCD/: AsciiLib.c GLCD.c
  group LPC1700CMSIS_FIRMWARE
    ../Libraries/LPC1700CMSIS_Firmware_Library/source/: debug_frmwrk.c lpc17xx_adc.c lpc17xx_can.c lpc17xx_clkpwr.c lpc17xx_dac.c lpc17xx_emac.c lpc17xx_exti.c lpc17xx_gpdma.c lpc17xx_gpio.c lpc17xx_i2c.c lpc17xx_i2s.c lpc17xx_libcfg_default.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_pwm.c lpc17xx_qei.c lpc17xx_rit.c lpc17xx_rtc.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_wdt.c
  group Source
    ../USER/: DMA.c main.c TouchPanel.c init_timers_pins.c i2c_lpc17xx.c
