# Keil uVision project Http_demo.uvproj, settings and files
target MCB1700 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Http_demo
  c flags: Optim=1
  c define: NO_RTX_KERNEL
  c include: ..\Library;.\Library;C:\Keil\ARM\RV31\lib;.\Libreria\LPC1700CMSIS_Firmware_Library\include;.\Libreria\GLCD;.\USER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group HTTP Files
    ./Web/: index.cgi Web.c Web.inp
  group Source Files
    ./: HTTP_demo.c HTTP_CGI.c
    ./USER/: DMA.c i2c_lpc17xx.c init.c PWM.c TouchPanel.c uart.c DS1621.c audio_muestras.h BMP180.c
  group Configuration Files
    ./: Net_Config.c Net_Debug.c startup_LPC17xx.s RTX_Conf_CM.c
    ./Library/: EMAC_LPC17xx_100Mb.c
  group Library
    ./Library/: system_LPC17xx.c
    ./Libreria/GLCD/: HzLib.c GLCD.c AsciiLib.c
    ./Libreria/LPC1700CMSIS_Firmware_Library/source/: lpc17xx_pinsel.c lpc17xx_gpio.c lpc17xx_ssp.c lpc17xx_libcfg_default.c lpc17xx_clkpwr.c
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib TCPD_CM3.lib
  group Documentation
    ./: Abstract.txt
target MCB1700 Debug (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: Http_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target MCB1700 RTX (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: Http_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
